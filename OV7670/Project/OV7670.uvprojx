# Keil uVision project OV7670.uvprojx, settings and files
target IK-ZET6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OV7670 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Lib\F10x_FWLIB\inc;..\User;..\User\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../User/: main.c
  group BSP
    ../User/bsp/: ov7670.c sccb.c user_exti.c user_ili9341_lcd.c esp8266.c led.c delay.h oled.c oledfont.c
  group F10x_FWLIB
    ../Lib/F10x_FWLIB/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_iwdg.c
  group DOC
    ../Doc/: ????.txt
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
